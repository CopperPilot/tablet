# Repository CopperPilot/tablet

File README.md:

# CopperPilot Tablet

**A compact 8.4-inch Android-class tablet around a chip-down Rockchip RK3566 with 4 GB LPDDR4X and 64 GB eMMC on an 8-layer, 0.8 mm mainboard strip, a 1600 x 2560 dual-DSI display, front and rear cameras with flash, stereo speakers, a 21 Wh battery and USB-C on its own daughter board, in a CNC aluminium shell. Designed end to end by CopperPilot from three photos and a prompt.**

> [!NOTE]
> **Designed by [CopperPilot](https://copperpilot.ai).** CopperPilot's agents designed every board, schematic, layout and enclosure part in this repo from one prompt and a few reference photos, then checked them with the gates and reviews below. Nobody edited the design files by hand. The prompt asked for a compact 8-inch-class tablet like the one in three photos (front, back and a teardown), set the display, the shell and a rough spec for the mainboard (SoC, memory, stack-up, impedance targets, placement along the strip), and after the first build the owner gave measured rear details (corner radius, camera ring, microphone and flash positions). The agents chose the parts, drew and routed both boards, modelled the shell and fixed every review finding themselves. **It has not been fabricated, assembled or powered on yet.** Everything here is open for review: if you see something a senior engineer would flag, [open an issue](../../issues/new/choose).

A 134 x 198 x 9.4 mm tablet with 14 mm corners and a flat CNC aluminium back:
- **Front:** a Sharp LQ084R1SX01 8.4-inch 1600 x 2560 oxide TFT (dual-channel MIPI-DSI, 2 x 4 lanes) under a cover
  glass with a bonded capacitive touch sensor.
- **Mainboard:** a 28 x 125 mm, 8-layer, 0.8 mm strip along one long edge under the display, with solder-down
  shields over the SoC/RAM and the PMIC; the battery fills the rest of the interior.
- **USB-C daughter board:** 25 x 12 mm, centred on the bottom edge, joined to the mainboard by a 16-pin FPC.
- **Back:** one raised camera ring, a rear microphone hole and a flash window on one line in the top corner; the
  Wi-Fi antenna sees out through a plastic insert in the top edge wall.

## Status

### Done

- [x] Schematic: KiCad ERC, 0 errors
- [x] Layout: KiCad DRC with schematic parity and zone refill, 0 errors, 0 unconnected
- [x] Board rules no looser than the fab's limits, nothing silenced
- [x] Every part on the footprint and 3D model of its exact LCSC part
- [x] Every placed part has a live, in-stock LCSC/JLCPCB part number
- [x] High-speed groups (USB, MIPI, DDR where present) routed, length-matched, on target impedance
- [x] Every user-facing connector opens towards its case opening (checked on its 3D model)
- [x] Every connector mates from a known side, with a keep-clear zone KiCad DRC enforces
- [x] Both ends of every board-to-board cable carry the same signal on each wire
- [x] Datasheet-level design review: 0 P0 and 0 P1 findings open on every board
- [x] Enclosure parts are closed solids that fit the product envelope
- [x] Every enclosure part is manufacturable by its process (wall thickness, build size)
- [x] Full assembly with the real PCBAs: no collisions, seated or along any insertion path
- [x] Every cable joins two real connectors and fits its route in every pose
- [x] Every connector faces what mates with it; every screw hole sits on a boss
- [x] Every port opening has its connector right behind it
- [x] Every button and control physically reaches the switch it works
- [x] Every camera's whole field of view clears the case
- [x] Every part is held by something real (screw, snap, clip, adhesive, press fit)
- [x] Gerbers, drill, BOM and CPL exist and agree with the PCB
- [x] Independent judge (compares renders to the reference photos): **9/10** ([notes](reviews/judge.md))

### Pending

- [ ] Gate `sourcing.bom` warn: 77 extended parts (each adds a JLCPCB feeder fee); prefer basic parts where equivalent
- [ ] Gate `kicad.drc` warn: [main] DRC warning lib_footprint_mismatch x199
- [ ] Gate `board.contract` warn: [main] U2 rotation 0.0 != spec 90.0
- [ ] **Not built.** Neither board has been fabricated or assembled and no shell has been machined.
- [ ] **No software bring-up.** No device tree, kernel or Android image exists for this board; the dual-DSI panel, both cameras, Wi-Fi/Bluetooth, the charger and audio are untested.
- [ ] **Display bandwidth risk.** 1600 x 2560 is about 11% above the RK3566's listed dual-DSI limit (2560 x 1440 at 60 Hz), so the panel may need a reduced refresh rate (50-54 Hz); the RK3576 is the upgrade path.
- [ ] **Display FPC pinout modelled from a sibling.** The 40-pin panel connector follows the closest Sharp dual-DSI sibling (LQ101R1SX01); it must be checked against the LQ084R1SX01's own datasheet before fabrication.
- [ ] **Touch controller comes with the sensor.** The touch sensor is a chip-on-flex part whose controller sits on its flex (I2C + INT + RST through the 10-pin FPC); the exact sensor and controller still have to be chosen. The MPR121 on the board is a grip/proximity sensor, not the touchscreen controller.
- [ ] **Bought parts are specified from drawings.** The battery, both camera modules, the speakers and the button flex are modelled from typical drawings; exact suppliers still have to be chosen and checked against those models.
- [ ] **Judge notes (9/10):** 9.4 mm thick against about 6.3 mm for the reference (set by the 3.2 mm panel and the battery stack, as the prompt asked); the reference's side stylus-charging strip is left out.
- [ ] **DRC warnings:** 343 on the mainboard, mostly footprints that differ from their library copy (199), co-located holes (95) and hole-to-hole spacing (15); 0 errors. The RAM's placed rotation differs from the spec's (0 vs 90 degrees).
- [ ] **Thermal design not analysed.** The SoC shield is tied to a graphite sheet on the aluminium back through a thermal pad; no thermal simulation was run.

0 P0 · 0 P1 · 0 P2 review findings open; the full reviews with evidence and suggested fixes are in [reviews/](reviews). Every P0 and P1 the reviews raised was fixed before release.

## Build film

[docs/build-film.mp4](docs/build-film.mp4) (48 s, 720p). Every part backs out along the direction it was fitted and goes back in assembly order, and every cable is drawn along its real route. Every frame is replayed against the 3D models (no part passes through another, the camera stays outside, the product stays in frame and faces you, no flicker), and a separate critic watches the film ([notes](reviews/film.md)).

## Renders

| | |
|:---:|:---:|
| <br>*Three-quarter view* | <br>*Front* |
| <br>*Rear* | <br>*Exploded* |
| <br>*Inside, top cover lifted away, every cable* | <br>*Inside from below, bottom cover lifted away* |
| <br>*Ports* | <br>*Buttons and controls, next to the parts they press* |

## What's inside

**Compute:** Rockchip RK3566 (chip-down) with 4 GB LPDDR4X x32 (K4FBE3D4HM) within 15 mm and 64 GB eMMC 5.1; RK809-5
PMIC for the SoC rails, with VDD_CPU on its own RK860 buck. High-speed groups (every DDR byte lane, the CA group, DSI0,
DSI1, camera CSI and USB 2.0) are declared with impedance targets and length tolerances and checked by the gates.
**Power:** BQ25895 1S charger for a 21.28 Wh (5600 mAh) pouch with NTC and protection board; 5 V / 3 A USB-C sink
with 5.1 kOhm CC pull-downs, surge and ESD protection on the daughter board.
**Peripherals:** RTL8723DS Wi-Fi/Bluetooth on SDIO with a chip antenna at the RF window; TPS61165 WLED boost for the
panel backlight; 8 MP rear and 5 MP front MIPI-CSI cameras; AW3641E flash driver; two NS4150B class-D amplifiers for
the top and bottom speakers; MEMS microphone; button flex for power and volume.

| Board | Size | Layers | Parts | Tracks | Vias | KiCad project | Review |
|---|---|---|---|---|---|---|---|
| Main board | 28 × 125 mm | 8 | 431 | 90,618 | 1,703 | [`hardware/compact-tablet.kicad_pro`](hardware/compact-tablet.kicad_pro) | [0 P0 · 0 P1](reviews/review-main.md) |
| USB-C daughter board | 25 × 12 mm | 2 | 26 | 150 | 40 | [`hardware/usbc_board/compact-tablet-usbc_board.kicad_pro`](hardware/usbc_board/compact-tablet-usbc_board.kicad_pro) | [0 P0 · 0 P1](reviews/review-usbc_board.md) |

**Bought parts** (modelled from their drawings; the assembly checks use these models):

- **Display panel**: Sharp LQ084R1SX01 8.4-inch 1600x2560 WQXGA oxide TFT LCD module with dual-channel MIPI-DSI and WLED backlight
- **Touch sensor**: Optically bonded 8.4-inch COF
- **Battery**: 1S 3.8V 5600mAh
- **Rear camera**: 8 MP autofocus MIPI-CSI rear camera module with 30-pin 0.5 mm FPC tail
- **Front camera**: 5 MP fixed-focus MIPI-CSI front camera module with 24-pin 0.5 mm FPC tail
- **Top speaker**: Top landscape-stereo micro-speaker enclosure module
- **Bottom speaker**: Bottom landscape-stereo micro-speaker enclosure module
- **Button flex**: Top power button and volume up/down metal-dome switch flex cable assembly

## How it was made

CopperPilot's agents worked from the prompt in [reference/prompt.md](reference/prompt.md) and 3 reference photos ([reference/](reference)). The pipeline scopes the product into a written contract ([design/spec.yaml](design/spec.yaml)), designs the boards and the enclosure in parallel, integrates them, and only moves on when the gates pass. A separate review agent reads every board against the part datasheets, and a separate judge compares the result with the photos.

- Pipeline wall clock: about **89 h** over 16 launches (pipeline v71 to v127).

**Reference vs build:**

<sub>Reference photos of a commercial product, used here only for comparison. All rights belong to their owners; this project is not affiliated with or endorsed by the product's maker.</sub>

## Repository layout

```
hardware/          KiCad 10 projects (main board at the top, daughter boards in their own folders)
  lcsc.*, rea_refs.*   symbols, footprints and 3D models for every part, so the project opens anywhere
case/out/          enclosure parts (STL)
case/purchased/    bought parts used in the assembly checks
case/generate_case.py  the parametric enclosure source (uses CopperPilot's CAD helpers, not yet public)
fab/               Gerbers, drill, BOM, CPL, schematic PDF and STEP for each board; fab/mech/ enclosure STEP/STL
design/spec.yaml   the design contract the agents wrote and the gates check
reviews/           gate report, design reviews, the judge's notes, KiCad ERC/DRC
reference/         the prompt and the reference photos
docs/              build film and renders
```

## Manufacture

Every board targets **JLCPCB** standard PCB + assembly (0.8 mm FR-4); every part has an LCSC number. Per board: upload `*-gerbers.zip`, then `*-bom.csv` and `*-cpl.csv` for assembly, and check the part rotations in JLCPCB's preview before ordering.

The back shell, buttons and bezel are designed for CNC (6061 aluminium, PC/ABS for the bezel and the RF window), the
flash window for SLA; STEP files for each part are in `fab/mech/`, with STLs for test prints. Both boards are set up
for JLCPCB fabrication and assembly (Gerbers, BOM and CPL per board); the mainboard uses JLCPCB's 8-layer 0.8 mm
process with via-in-pad and impedance control.

> [!WARNING]
> This design has not been built yet. Fix or accept the open review findings above before you order boards, and expect a first revision to need changes.

## Review this design

Hardware gets better with more eyes on it. We'd like to hear what you'd flag:

- **Open an issue** ([design review template](../../issues/new/choose)) for a wrong pin, a missing part, a tight clearance, a part you'd swap, or a P1 above you disagree with.
- **Send a pull request** with a fix. Say which board and which reference designators it touches.
- **Build one** and tell us how it went: photos, bring-up notes and failures are all welcome.

Start with [reviews/](reviews): every finding has its evidence and a suggested fix.

## License

[CERN-OHL-S-2.0](LICENSE). You may use, study, modify, make and sell products from this design; modified versions must be shared under the same licence.

Part and product names are used only to say what fits; all trademarks belong to their owners.

<p align="center"><a href="https://copperpilot.ai"><b>Designed by CopperPilot</b></a>: we accelerate hardware design.<br><sub>More open designs: <a href="https://github.com/CopperPilot">github.com/CopperPilot</a></sub></p>

## KiCad design hardware/compact-tablet.kicad_pcb

File hardware/README.md (part):

# Mainboard & Sub-board Hardware Documentation (`compact-tablet`)

Generated from `rea/spec.yaml` by rea-hardware (fab rules, stackup, outline at the origin, mounting holes), then completed by the electrical agent. Every placed part carries an `LCSC` field and verified 3D model.

## 1. Inter-Board Cable Pinout (`usbc_fpc_cable`: Mainboard `J6` <-> USB-C Board `J2`, 16-pin 0.5 mm FPC `0.5K-QX-16PWB`)

Straight-through 1:1 pinout (Pin $i$ on `main:J6` connects to Pin $i$ on `usbc_board:J2`) over a **2 oz (`0.070 mm`) heavy-copper Type-B 16-pin 0.5 mm FFC (`FFC-0.5-16P-92MM-TYPE-B`, `0.65 A/pin`)**.
Six contacts are allocated in parallel to `VBUS` (`6 x 0.50 A = 3.00 A` connector contact rating and `6 x 0.65 A = 3.90 A` 2 oz FFC rating, protected by `usbc_board:U2` `TPS259470ARPWR`'s `2.43 A` typ / `2.68 A` max active OCP limit via `R9 = 1.37 kOhm`) and eight contacts (`Pin 3` guard + `Pins 6..10` + `Pins 17, 18` shield tabs) to `GND`:

| Pin (`main:J6` / `usbc_board:J2`) | Net Name | Function / Rating |
|---|---|---|
| 1 | `USB_OTG0_DP` | USB 2.0 OTG D+ (`U1.USB_OTG0_DP` <-> `J6.1`) |
| 2 | `USB_OTG0_DM` | USB 2.0 OTG D- (`U1.USB_OTG0_DM` <-> `J6.2`) |
| 3 | `GND` | Ground guard for USB 2.0 differential pair (`0.5 A`) |
| 4 | `USB_CC1` | USB-C CC1 channel (`5.1 kOhm` Rd pull-down on `usbc_board`) |
| 5 | `USB_CC2` | USB-C CC2 channel (`5.1 kOhm` Rd pull-down on `usbc_board`) |
| 6 | `GND` | Power return ground (`0.5 A`) |
| 7 | `GND` | Power return ground (`0.5 A`) |
| 8 | `GND` | Power return ground (`0.5 A`) |
| 9 | `GND` | Power return ground (`0.5 A`) |
| 10 | `GND` | Power return ground (`0.5 A`; total `6 x 0.5 A = 3.0 A` GND return) |
| 11 | `VBUS` | 5 V USB-C sink input (`0.5 A`) |
| 12 | `VBUS` | 5 V USB-C sink input (`0.5 A`) |
| 13 | `VBUS` | 5 V USB-C sink input (`0.5 A`) |
| 14 | `VBUS` | 5 V USB-C sink input (`0.5 A`) |
| 15 | `VBUS` | 5 V USB-C sink input (`0.5 A`) |
| 16 | `VBUS` | 5 V USB-C sink input (`0.5 A`; total `6 x 0.5 A = 3.0 A` VBUS supply) |
| 17, 18 | `GND` | Mechanical shield / retention tabs |

## 2. Capacitor Voltage Derating Checks (`>= 1.5x` Max Net Voltage)

Every capacitor on `main` (`hardware/compact-tablet.kicad_sch`) is rated at least `1.5x` the maximum voltage on its net:

| Ref | MPN (LCSC) | Value / Package | Net | Max Net Voltage | Required (`1.5x`) | Part Rating | Margin |
|---|---|---|---|---|---|---|---|
| `C1` | `CL10A106KP8NNNC` (`C19702`) | `10 uF` 0603 X5R | `VDD_CPU` | `1.15 V` | `1.73 V` | `10 V` | `8.7x` PASS |
| `C2` | `CL10A106KP8NNNC` (`C19702`) | `10 uF` 0603 X5R | `VDD_LOGIC` | `0.95 V` | `1.43 V` | `10 V` | `10.5x` PASS |
| `C3` | `CL10A106KP8NNNC` (`C19702`) | `10 uF` 0603 X5R | `VDD_GPU` | `0.95 V` | `1.43 V` | `10 V` | `10.5x` PASS |
| `C4` | `CL10A106KP8NNNC` (`C19702`) | `10 uF` 0603 X5R | `VCC_DDR` | `1.10 V` | `1.65 V` | `10 V` | `9.1x` PASS |
| `C5` | `CL10A106KP8NNNC` (`C19702`) | `10 uF` 0603 X5R | `VCC_3V3` | `3.30 V` | `4.95 V` | `10 V` | `3.0x` PASS |
| `C6` | `CL10A106KP8NNNC` (`C19702`) | `10 uF` 0603 X5R | `VSYS` | `4.50 V` | `6.75 V` | `10 V` | `2.2x` PASS |
| `C7, C159` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VBUS` (`J6.11..16` & `U11.1` local input decoupling at `1.04 mm`) | `6.75 V` | `10.13 V` | `25 V` | `3.7x` PASS |
| `C8` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VBAT` | `4.35 V` | `6.53 V` | `25 V` | `5.7x` PASS |
| `C9` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC_1V8` | `1.80 V` | `2.70 V` | `25 V` | `13.9x` PASS |
| `C10` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC_2V8` | `2.80 V` | `4.20 V` | `25 V` | `8.9x` PASS |
| `C11` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC_AF_2V8` | `2.80 V` | `4.20 V` | `25 V` | `8.9x` PASS |
| `C12` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `FLASH_C1/C2` | `5.00 V` | `7.50 V` | `25 V` | `5.0x` PASS |
| `C13` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `VDD_CPU` | `1.15 V` | `1.73 V` | `16 V` | `13.9x` PASS |
| `C14` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `VDD_LOGIC` | `0.95 V` | `1.43 V` | `16 V` | `16.8x` PASS |
| `C15` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `VCC_DDR` | `1.10 V` | `1.65 V` | `16 V` | `14.5x` PASS |
| `C16` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `VCC_1V8` | `1.80 V` | `2.70 V` | `16 V` | `8.9x` PASS |
| `C17` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `VCC_3V3` | `3.30 V` | `4.95 V` | `16 V` | `4.8x` PASS |
| `C18` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `EMMC_VDDI` | `1.80 V` | `2.70 V` | `16 V` | `8.9x` PASS |
| `C19` | `CL10A105KB8NNNC` (`C15849`) | `1 uF` 0603 X5R | `WLED_A` | `24.0 V` (`38 V` OVP) | `36.0 V` | `50 V` | `2.1x` PASS |
| `C20, C21` | `0402CG180J500NT` (`C1549`) | `18 pF` 0402 C0G | `XTAL_24M_IN/OUT` | `1.80 V` | `2.70 V` | `50 V` | `27.8x` PASS |
| `C22, C23` | `0402CG180J500NT` (`C1549`) | `18 pF` 0402 C0G | `RTC_XIN/XOUT` | `1.80 V` | `2.70 V` | `50 V` | `27.8x` PASS |
| `C24, C25` | `0402CG150J500NT` (`C1548`) | `15 pF` 0402 C0G | `WIFI_XTAL_IN/OUT` | `1.80 V` | `2.70 V` | `50 V` | `27.8x` PASS |
| `C26` | `CL10A106MA8NRNC` (`C96446`) | `10 uF` 0603 X5R | `CHG_PMID` | `5.25 V` | `7.88 V` | `25 V` | `4.8x` PASS |
| `C27` | `CC0402KRX7R9BB473` (`C272875`) | `47 nF` 0402 X7R | `CHG_BTST/CHG_SW` | `6.00 V` | `9.00 V` | `50 V` | `8.3x` PASS |
| `C28` | `CL10A475KO8NNNC` (`C19666`) | `4.7 uF` 0603 X5R | `CHG_REGN` | `6.00 V` | `9.00 V` | `16 V` | `2.7x` PASS |
| `C29` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCCA1V8_CODEC` (`LDO4`) | `1.80 V` | `2.70 V` | `25 V` | `13.9x` PASS |
| `C30` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC3V3_PMU` (`LDO6`) | `3.30 V` | `4.95 V` | `25 V` | `7.6x` PASS |
| `C31` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC1V8_CAM` (`LDO9`) | `1.80 V` | `2.70 V` | `25 V` | `13.9x` PASS |
| `C32` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `PMIC_VREF` | `1.20 V` | `1.80 V` | `25 V` | `20.8x` PASS |
| `C33` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `PMIC_CPP/CPN` | `1.80 V` | `2.70 V` | `25 V` | `13.9x` PASS |
| `C34` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `PMIC_CPVSS` | `1.80 V` | `2.70 V` | `25 V` | `13.9x` PASS |
| `C35` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `VCC1V8_LCD` (`U9.5/20` `VREG/VDD`) | `1.80 V` | `2.70 V` | `16 V` | `8.9x` PASS |
| `C36` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCCA3V3_PHY` (`LDO5` at `U4.29`) | `3.30 V` | `4.95 V` | `25 V` | `7.6x` PASS |
| `C37` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC3V3_TP` (`SWOUT2` at `U15.6` `IN`) | `3.52 V` | `5.28 V` | `25 V` | `7.1x` PASS |
| `C38` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VCC3V3_LCD` (`U15.1` `OUT` `TLV75533PDRVR` at `J1.35/36`, `J2.6`) | `3.30 V` | `4.95 V` | `25 V` | `7.6x` PASS |
| `C39` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VDDA0V9_IMAGE` (`LDO1`) | `0.90 V` | `1.35 V` | `25 V` | `27.8x` PASS |
| `C40` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VDDA_0V9` (`LDO2`) | `0.90 V` | `1.35 V` | `25 V` | `27.8x` PASS |
| `C41` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `VDDA0V9_PMU` (`LDO3`) | `0.90 V` | `1.35 V` | `25 V` | `27.8x` PASS |
| `C42` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `DDR_VREFOUT` (`U1.1H3`) | `0.55 V` | `0.83 V` | `16 V` | `29.1x` PASS |
| `C43` | `CL05A105KA5NQNC` (`C52923`) | `1 uF` 0402 X5R | `AUD_BYPASS` (`U10.2`) | `2.25 V` | `3.38 V` | `25 V` | `11.1x` PASS |
| `C44, C45` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `GND` / `AUD_LINE_N` AC coupling | `2.25 V` | `3.38 V` | `16 V` | `7.1x` PASS |
| `C46` | `CL10A475KO8NNNC` (`C19666`) | `4.7 uF` 0603 X5R | `WIFI_1V25` (`U5` buck) | `1.25 V` | `1.88 V` | `16 V` | `12.8x` PASS |
| `C47` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `WIFI_1V25` (`U5` buck) | `1.25 V` | `1.88 V` | `16 V` | `12.8x` PASS |
| `C48` | `CL05B104KO5NNNC` (`C1525`) | `100 nF` 0402 X7R | `WLED_COMP` (`U6.2`) | `2.50 V` | `3.75 V` | `16 V` | `6.4x` PASS |
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
Schematic: compact-tablet.kicad_sch, Compact 8.4-inch Android Tablet

Parts:
ANT1: ANT3216A063R2400A; ANT-SMD_3P-L3.1-W1.6_ANT3216A063R2400A; MPN ANT3216A063R2400A; LCSC C412135
C1, C2, C3, C4, C5, C6, C58, C63, C64, C70, C71, C82, C129, C130, C163, C165, C166, C167, C168, C178, C179, C180, C182: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C7, C8, C9, C10, C11, C12, C29, C30, C31, C32, C33, C34, C36, C37, C38, C39, C40, C41, C43, C55, C59, C60, C62, C76, C77, C78, C79, C127, C128, C140, C142, C147, C148, C149, C151, C159, C160, C174, C177, C181, C183, C184: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C13, C14, C15, C16, C17, C35, C42, C44, C45, C47, C48, C52, C56, C57, C61, C72, C75, C83, C84, C85, C86, C87, C88, C91, C92, C93, C94, C97, C98, C99, C100, C101, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C118, C119, C122, C123, C125, C126, C131, C132, C139, C141, C143, C144, C145, C146, C150, C152, C154, C156, C157, C158, C161, C162, C164, C169, C175, C176: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C18: 2.2uF; C_0402_1005Metric; MPN CL05A225MQ5NSNC; LCSC C107369
C19: 1uF; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C20, C21, C22, C23, C24, C25: 15pF; C_0402_1005Metric; MPN 0402CG150J500NT; LCSC C1548
C26: 10uF; C_0603_1608Metric; MPN CL10A106MA8NRNC; LCSC C96446
C27: 47nF; C_0402_1005Metric; MPN CC0402KRX7R9BB473; LCSC C272875
C28, C46, C153, C155: 4.7uF; C_0603_1608Metric; MPN CL10A475KO8NNNC; LCSC C19666
C49: 4.7uF; C_0402_1005Metric; MPN GRM155R61E475ME15D; LCSC C2858031
C50, C51, C65, C80, C81, C89, C90, C95, C96, C102, C103, C104, C120, C121, C124: 22uF; C_0603_1608Metric; MPN CL10A226MQ8NRNC; LCSC C59461
C53, C54, C73, C74, C133, C134, C135, C136, C137, C138: 1nF; C_0402_1005Metric; MPN 0402B102K500NT; LCSC C1523
C66, C67: 18pF; C_0402_1005Metric; MPN 0402CG180J500NT; LCSC C1549
C68, C69: 1.5pF; C_0402_1005Metric; MPN 0402CG1R5C500NT; LCSC C1552
C170, C171, C172, C173: 10uF; C_0402_1005Metric; MPN GRM155R61A106ME44D; LCSC C77000
D1: KW CELNM3.TK-S4S9-4L07M0-2686; LED-SMD_3P-L1.9-W1.5_KW-CELMM1.TG; MPN KW CELNM3.TK-S4S9-4L07M0-2686; LCSC C17383700
D2: B16WS; D_SOD-323; MPN B16WS; LCSC C364278
D3: TPTVS0571P; DFN-2_L1.6-W1.0-P1.10-RD; MPN TPTVS0571P; LCSC C2844712
D5, D6, D7, D8, D15, D17, D18, D29, D30, D31, D35, D36, D37, D38: PTVS5V5D1BLYL; SOD-882_L1.0-W0.6-BI-1; MPN PTVS5V5D1BLYL; LCSC C553450
D9, D10, D11, D12, D16, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D32, D33, D34, D39, D40, D46, D47, D48: PESD5V0F1BL,315; SOD-882_L1.0-W0.6-BI; MPN PESD5V0F1BL,315; LCSC C45961
D13: SMF7.5A; SOD-123F_L2.8-W1.8-LS3.7-RD; MPN SMF7.5A; LCSC C123796
D14: H36VND3B; SOD-323_L1.8-W1.3-LS2.7-BI; MPN H36VND3B; LCSC C20615816
D43, D44, D45, D49: BAS70L,315; SOD-882_L1.0-W0.6-RD; MPN BAS70L,315; LCSC C456141
F1: BSMD0603L-300; F0603; MPN BSMD0603L-300; LCSC C5374008
J1: FPC-0.5HF-40PWBH10; FPC-SMD_40P-P0.50_FPC-0.5HF-40PWBH10; MPN FPC-0.5HF-40PWBH10; LCSC C5343289
J2: 0.5K-QX-10PWB; FPC-SMD_10P-P0.50_HDGC_0.5K-QX-10PWB; MPN 0.5K-QX-10PWB; LCSC C2919478
J3: 0.5K-QX-30PWB; FPC-SMD_30P-P0.50_HDGC_0.5K-QX-30PWB; MPN 0.5K-QX-30PWB; LCSC C2919487
J4: FPC-0.5HF-24PWBH10; FPC-SMD_24P-P0.50_XUNPU_FPC-0.5HF-24PWBH10; MPN FPC-0.5HF-24PWBH10; LCSC C5343283
J5: DF58-4P-1.2V(21); CONN-SMD_4P-P1.20_DF58-4P-1.2V-21; MPN DF58-4P-1.2V(21); LCSC C20723302
J6: 0.5K-QX-16PWB; FPC-SMD_16P-P0.50_HDGC_0.5K-QX-16PWB; MPN 0.5K-QX-16PWB; LCSC C2919481
J7, J8, J9: 0.5K-QX-4PWB; FPC-SMD_4P-P0.50_HDGC_0.5K-QX-4PWB; MPN 0.5K-QX-4PWB; LCSC C2919475
L1, L2, L3, L4, L5: 470nH; IND-SMD_L2.0-W1.6_WPN2016X; MPN WPN201610HR47MT; LCSC C97009
L6: 470nH; L_1008_2520Metric; MPN WPN252012ER47MT; LCSC C317620
L7: 10uH; L_1008_2520Metric; MPN SWPA252012S100MT; LCSC C37428
L8: 1uH; L_1008_2520Metric; MPN WPN252012E1R0MT; LCSC C370610
L9: 2.2uH; IND-SMD_L2.0-W1.6_WPN2016X; MPN WPN201610H2R2MT; LCSC C97005
L10: 0.47uH; IND-SMD_L2.0-W1.6_WPN2016X; MPN WPN201610HR47MT; LCSC C97009
L11: 2.2nH; IND-SMD_L1.0-W0.5_LQG15HN1N6B02D; MPN LQG15HS2N2S02D; LCSC C86061
L12: 1uH; IND-SMD_L2.0-W1.6_WPN2016X; MPN WPN201610U1R0MT; LCSC C97016
L13, L14, L15, L16, L17: 120R@100MHz; L0603; MPN BLM18PG121SN1D; LCSC C14709
MK1: MSM261DCB002; MIC-SMD_5P-L2.8-W1.9_MSM261DCB002; MPN MSM261DCB002; LCSC C51928216
Q1: PPM6N20V10; DFN-6_L2.0-W2.0-P0.65-BL-EP-1; MPN PPM6N20V10; LCSC C918800
Q2: RUM002N02T2L; SOT-723_L1.2-W0.8-P0.40-LS1.2-BR; MPN RUM002N02T2L; LCSC C250130
R1: 120R; R_0402_1005Metric; MPN 0402WGF1200TCE; LCSC C25079
R2, R3, R15, R16, R17, R18, R84, R85: 2.2k; R_0402_1005Metric; MPN 0402WGF2201TCE; LCSC C25879
R4, R5, R11, R12, R27, R28, R29, R30, R31, R38, R40, R42, R43, R45, R49, R50, R51, R52, R57, R61, R64, R82, R83, R89: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R6: 3.3R; R_0402_1005Metric; MPN 0402WGF330KTCE; LCSC C270612
R7, R66, R71: 1M; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
R8: 196R; R_0402_1005Metric; MPN 0402WGF1960TCE; LCSC C270631
R9: 5.1k; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C25905
R10, R21, R22, R35, R86, R87: 30k; R_0402_1005Metric; MPN 0402WGF3002TCE; LCSC C25776
R13: 10mR; R_0603_1608Metric; MPN RL0603FR-070R01L; LCSC C728437
R14, R36: 75k; R_0402_1005Metric; MPN 0402WGF7502TCE; LCSC C25798
R19, R20: 240R; R_0402_1005Metric; MPN 0402WGF2400TCE; LCSC C25094
R23: 110k; R_0402_1005Metric; MPN 0402WGF1103TCE; LCSC C25745
R24: 0.22R; R_0603_1608Metric; MPN PT0603FR-7W0R22L; LCSC C858642
R25, R46, R93, R95: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
R26: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168; not fitted
R32, R33, R53, R54, R55, R56, R58, R59, R60: 100R; R_0402_1005Metric; MPN 0402WGF1000TCE; LCSC C25076
R34, R91, R92: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
R37: 200k; R_0402_1005Metric; MPN 0402WGF2003TCE; LCSC C25764
R39: 63.4k; R_0402_1005Metric; MPN 0402WGF6342TCE; LCSC C38606
R41: 49.9R; R_0402_1005Metric; MPN 0402WGF499JTCE; LCSC C25120
R44, R90: 12k; R_0402_1005Metric; MPN 0402WGF1202TCE; LCSC C25752
R47: 300k; R_0402_1005Metric; MPN 0402WGF3003TCE; LCSC C25774
R48, R68, R69, R70, R72, R73, R74, R75, R76, R77, R78, R80, R81, R88: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R62, R63, R79: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R65: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R67, R94: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168
SH1, SH2: KH-PBJ-440808; CONN-SMD_3P-L4.4-W0.8_C9900042675; MPN KH-PBJ-440808; LCSC C19631108
TP1: TP_UART2_TX; TestPoint_Pad_D1.0mm; not fitted
TP2: TP_UART2_RX; TestPoint_Pad_D1.0mm; not fitted
TP3: TP_MASKROM; TestPoint_Pad_D1.0mm; not fitted
TP4: TP_GND; TestPoint_Pad_D1.0mm; not fitted
TP5: TP_VBUS; TestPoint_Pad_D1.0mm; not fitted
TP6: TP_VBAT_CONN; TestPoint_Pad_D1.0mm; not fitted
TP7: TP_VBAT_PROT; TestPoint_Pad_D1.0mm; not fitted
TP8: TP_VBAT; TestPoint_Pad_D1.0mm; not fitted
TP9: TP_VSYS; TestPoint_Pad_D1.0mm; not fitted
TP10: TP_CHG_PMID; TestPoint_Pad_D1.0mm; not fitted
TP11: TP_CHG_REGN; TestPoint_Pad_D1.0mm; not fitted
TP12: TP_VDD_CPU; TestPoint_Pad_D1.0mm; not fitted
TP13: TP_VDD_LOGIC; TestPoint_Pad_D1.0mm; not fitted
TP14: TP_VDD_GPU; TestPoint_Pad_D1.0mm; not fitted
TP15: TP_VCC_DDR; TestPoint_Pad_D1.0mm; not fitted
TP16: TP_PMIC_VBUCK4; TestPoint_Pad_D1.0mm; not fitted
TP17: TP_VCC_1V8; TestPoint_Pad_D1.0mm; not fitted
TP18: TP_VCC_3V3; TestPoint_Pad_D1.0mm; not fitted
TP19: TP_VCC0V6_DDR; TestPoint_Pad_D1.0mm; not fitted
TP20: TP_VCC_AF_2V8; TestPoint_Pad_D1.0mm; not fitted
TP21: TP_VDDA_0V9; TestPoint_Pad_D1.0mm; not fitted
TP22: TP_VDDA0V9_PMU; TestPoint_Pad_D1.0mm; not fitted
TP23: TP_VCCA1V8_CODEC; TestPoint_Pad_D1.0mm; not fitted
TP24: TP_VCCA3V3_PHY; TestPoint_Pad_D1.0mm; not fitted
TP25: TP_VCC3V3_PMU; TestPoint_Pad_D1.0mm; not fitted
TP26: TP_VCC1V8_CAM; TestPoint_Pad_D1.0mm; not fitted
TP27: TP_VCCA1V8_IMAGE; TestPoint_Pad_D1.0mm; not fitted
TP28: TP_VCC_2V8; TestPoint_Pad_D1.0mm; not fitted
TP29: TP_VCCA1V8_PMU; TestPoint_Pad_D1.0mm; not fitted
TP30: TP_VCC_RTC; TestPoint_Pad_D1.0mm; not fitted
TP31: TP_PMIC_SWOUT1; TestPoint_Pad_D1.0mm; not fitted
TP32: TP_VCC3V3_TP; TestPoint_Pad_D1.0mm; not fitted
TP33: TP_VCC1V8_LCD; TestPoint_Pad_D1.0mm; not fitted
TP34: TP_VCC3V3_LCD; TestPoint_Pad_D1.0mm; not fitted
TP35: TP_WIFI_1V25; TestPoint_Pad_D1.0mm; not fitted
TP36: TP_WLED_A; TestPoint_Pad_D1.0mm; not fitted
TP37: TP_FLASH_LED_A; TestPoint_Pad_D1.0mm; not fitted
TP38: TP_EMMC_VDDI; TestPoint_Pad_D1.0mm; not fitted
TP39: TP_VCC1V8_DDR; TestPoint_Pad_D1.0mm; not fitted
TP40: TP_VCC3V3_SYS; TestPoint_Pad_D1.0mm; not fitted
TP41: TP_VCC3V3_EMMC; TestPoint_Pad_D1.0mm; not fitted
U1: RK3566; BGA-565_L15.5-W14.4-P0.40_RK3566_1; MPN RK3566; LCSC C2943786
U2: K4FBE3D4HM-MGCJ; FBGA-200_L15.0-W10.0-BL_K4F6E3S4HM; MPN K4FBE3D4HM-MGCJ; LCSC C19188580
U3: FEMDNN064G-C9A61; BGA-153_L13.0-W11.5-P0.50-TL_FORESEE_FEMDME; MPN FEMDNN064G-C9A61; LCSC C49284704
U4: RK809-5; QFN-68_L7.0-W7.0-P0.35-BL-EP5.5; MPN RK809-5; LCSC C2939628
U5: RTL8723DS-CG; WQFN-48_L6.0-W6.0-P0.40-BL-EP4.2; MPN RTL8723DS-CG; LCSC C2762334
U6: TPS61165DRVR; WSON-6_L2.0-W2.0-P0.65-TL-EP; MPN TPS61165DRVR; LCSC C122568
U7: AW3641EDNR; WDFN-10_L3.0-W3.0-P0.50-BL-EP; MPN AW3641EDNR; LCSC C164096
U8: RK860-0; WLCSP-20_L2.0-W1.6-R5-C4-P0.40-TL; MPN RK860-0; LCSC C19188628
U9: MPR121QR2; QFN-20_L3.0-W3.0-P0.40-BL; MPN MPR121QR2; LCSC C91322
U10, U23: NS4150B; MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL; MPN NS4150B; LCSC C189961
U11: BQ25895RTWR; QFN-24_L4.0-W4.0-P0.50-TL-EP2.7; MPN BQ25895RTWR; LCSC C80200
U12: TPS63802DLAR; VSON-10_L3.0-W2.0-P0.50-TL; MPN TPS63802DLAR; LCSC C2845237
U13: TLV62569ADRLR; SOT-563_L1.6-W1.2-P0.50-LS1.6-BL; MPN TLV62569ADRLR; LCSC C398367
U14: TPS22919DCKR; SC-70-6_L2.2-W1.3-P0.65-LS2.1-BR; MPN TPS22919DCKR; LCSC C2149796
U15, U21, U24: TLV75533PDRVR; WSON-6_L2.0-W2.0-P0.65-TL-EP; MPN TLV75533PDRVR; LCSC C2861750
U16: TMUX1112RSVR; UQFN-16_L2.6-W1.8-P0.40-BL; MPN TMUX1112RSVR; LCSC C1849384
U17, U18, U19: SN74LV1T34DCKR; SC-70-5_L2.1-W1.3-P0.65-LS2.1-BR; MPN SN74LV1T34DCKR; LCSC C78541
U20: TLV70018DCKR; SC-70-5_L2.1-W1.3-P0.65-LS2.1-BR; MPN TLV70018DCKR; LCSC C133796
U22: TMUX1511RSVR; UTQFN-16_L2.6-W1.8-P0.40-BL; MPN TMUX1511RSVR; LCSC C2673275
U25: LM66200DRLR; SOT-583-8_L2.1-W1.2-P0.50-LS1.6-BL; MPN LM66200DRLR; LCSC C3235556
Y1, Y3: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322524MOB4SI; LCSC C70590
Y2: 32.768kHz; FC-135R_L3.2-W1.5; MPN Q13FC13500004; LCSC C32346

Connections (part):
/AUD_AMP_INN: R22.2, U10.4 (INN)
/AUD_AMP_INP: R21.2, U10.3 (INP)
/AUD_BYPASS: C43.1, U10.2 (Bypass)
/AUD_INN_AC: C45.2, R22.1
/AUD_INP_AC: C44.2, R21.1
/AUD_LINE_L: C161.1, U4.39 (HPL_OUT)
/AUD_LINE_N: C44.1, U4.41 (HPR_OUT)
/AUD_TOP_AMP_INN: R87.2, U23.4 (INN)
/AUD_TOP_AMP_INP: R86.2, U23.3 (INP)
/AUD_TOP_BYPASS: C160.1, U23.2 (Bypass)
/AUD_TOP_INN_AC: C162.2, R87.1
/AUD_TOP_INP_AC: C161.2, R86.1
/BAT_NTC: C131.1, D5.1, J5.2, R9.2, R10.1, U11.11 (TS)
/BAT_SNSN: R67.2, U4.63 (SNSN)
/BAT_SNSP: J5.3, J5.4, R13.1, U4.62 (SNSP)
/BT_DIS_L: R77.1, U5.43 (~BT_DIS/GPIO11), U19.4 (Y)
/BT_HOST_WAKE: R82.1, U1.1N20 (GPIO0_D5_d), U5.19 (TEST_MOD_SEL/GPIO14)
/BT_REG_ON: R76.1, U1.1M19 (GPIO0_D4_d), U19.2 (A)
/BT_UART_CTS: U1.F37 (GPIO2_B5_u), U5.26 (UART_CTS)
/BT_UART_RTS: R89.2, R90.1, U1.G37 (GPIO2_B6_u)
/BT_UART_RTS_3V3: R89.1, U5.44 (GPIO8/WL_LED)
/BT_UART_RX: U1.1C20 (GPIO2_B3_u), U5.27 (UART_OUT)
/BT_UART_TX: U1.F38 (GPIO2_B4_u), U5.25 (UART_IN)
/BT_WAKE_DEV: R83.1, U1.1P20 (GPIO0_D6_d), U5.18 (GPIO13)
/BUCK_0V6_EN: R73.1, U13.5 (EN), U17.4 (Y)
/BUCK_0V6_SW: L12.1, U13.4 (SW)
/BUCK_3V3_FB: R39.2, R40.1, U12.4 (FB)
/BUCK_3V3_L2: L10.2, U12.7 (L2)
/BUCK_3V3_SW: L10.1, U12.9 (L1)
/CAM_FRONT_PDN: D34.1, J4.17, U1.AH2 (GPIO4_A6_d)
/CAM_FRONT_RST_L: D33.1, J4.16, U1.AG2 (GPIO4_B1_d)
/CAM_MCLK0: D26.1, J3.15, U1.1N1 (GPIO4_A7_d)
/CAM_MCLK1: D32.1, J4.15, U1.1L2 (GPIO4_B0_d)
/CAM_REAR_PDN: D28.1, J3.17, U1.AB2 (GPIO4_C0_d)
/CAM_REAR_RST_L: D27.1, J3.16, U1.AB1 (GPIO4_C1_d)
/CHG_BTST: C27.1, U11.21 (BTST)
/CHG_ILIM: R8.1, U11.10 (ILIM)
/CHG_INT_L: R11.1, U1.1R17 (GPIO0_B7_d), U11.7 (INT)
/CHG_PMID: C26.1, TP10.1, U11.23 (PMID)
/CHG_QON_L: D45.2, U11.12 (QON)
/CHG_REGN: C28.1, D43.2, R9.1, TP11.1, U11.22 (REGN)
/CHG_STAT_L: R12.1, U11.4 (STAT)
/CHG_SW: C27.2, L8.1, U11.19 (SW), U11.20 (SW)
/CLK_32K: R45.1, U1.1T20 (GPIO0_B0_u), U4.68 (CLK32K)
/CPU_SW: L6.1, U8.D3 (LX), U8.D4 (LX), U8.E3 (LX), U8.E4 (LX)
/DDR_RZQ: R1.1, U1.1F3 (DDR_RZQ)
/EMMC_CLK: R25.2, R26.1, U3.M6 (CLK)
/EMMC_CLK_SOC: R25.1, U1.A29 (GPIO1_C5_d)
/EMMC_CMD: R27.1, U1.A27 (GPIO1_C4_u), U3.M5 (CMD)
/EMMC_D0: R51.1, U1.A32 (GPIO1_B4_u), U3.A3 (DAT0)
/EMMC_D1: U1.B27 (GPIO1_B5_u), U3.A4 (DAT1)
/EMMC_D2: U1.B32 (GPIO1_B6_u), U3.A5 (DAT2)
/EMMC_D3: U1.B29 (GPIO1_B7_u), U3.B2 (DAT3)
/EMMC_D4: U1.B33 (GPIO1_C0_u), U3.B3 (DAT4)
/EMMC_D5: U1.A30 (GPIO1_C1_u), U3.B4 (DAT5)
/EMMC_D6: U1.B30 (GPIO1_C2_u), U3.B5 (DAT6)
/EMMC_D7: U1.A33 (GPIO1_C3_u), U3.B6 (DAT7)
/EMMC_DS: R28.1, U1.1A16 (GPIO1_C6_d), U3.H5 (DS)
/EMMC_MASKROM_TP: D46.1, R26.2, TP3.1
/EMMC_RSTN: U1.1B16 (GPIO1_C7_d), U3.K5 (RSTN)
/EMMC_VDDI: C18.1, C75.1, TP38.1, U3.C2 (VDDI)
/FLASH_C1: C12.1, U7.2 (C1)
/FLASH_C2: C12.2, U7.3 (C2)
/FLASH_EN: R91.1, U1.AM37 (GPIO0_C2_d), U7.5 (EN)
/FLASH_LED_A: C49.1, D1.1 (A), TP37.1, U7.10 (VOUT)
/FLASH_LED_K: D1.2 (K), R24.1, U7.7 (FB)
/FLASH_RSET: R23.1, U7.6 (RSET)
/FLASH_STROBE: R92.1, U1.AN38 (GPIO0_C3_d), U7.4 (FLASH)
/FLASH_VOL_SEL: R52.2, U1.AF38 (GPIO0_A7_u)
/GND: ANT1.2, ANT1.3, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C45.1, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C68.1, C69.1, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C80.1, C81.1, C82.1, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.1, C90.1, C91.2, C92.2, C93.2, C94.2, C95.1, C96.1, C97.2, C98.2, C99.2, C100.2, C101.2, C102.1, C103.1, C104.1, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.1, C121.1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
/I2C0_SCL: R2.1, U1.AJ37 (GPIO0_B1_u), U4.1 (SCL), U8.A3 (SCL), U11.5 (SCL)
/I2C0_SDA: R3.1, U1.AK38 (GPIO0_B2_u), U4.2 (SDA), U8.B1 (SDA), U11.6 (SDA)
/I2C1_SCL: R15.1, U1.AK37 (GPIO0_B3_u), U9.2 (SCL), U16.1 (S1)
/I2C1_SDA: R16.1, U1.AM38 (GPIO0_B4_u), U9.3 (SDA), U16.12 (S2)
/I2C2_SCL: D24.1, J3.12, R17.1, U1.AD1 (GPIO4_B5_d)
/I2C2_SDA: D25.1, J3.13, R18.1, U1.AF1 (GPIO4_B4_d)
/I2C4_SCL: D47.1, J4.12, R84.1, U1.AE2 (GPIO4_B3_d)
/I2C4_SDA: D48.1, J4.13, R85.1, U1.AF2 (GPIO4_B2_d)
/I2S1_LRCK: U1.B24 (GPIO1_A5_d), U4.14 (LRCLK)
/I2S1_MCLK: U1.A23 (GPIO1_A2_d), U4.16 (MCLK)
/I2S1_SCLK: U1.B23 (GPIO1_A3_d), U4.15 (BCLK)
/I2S1_SDI0: U1.1B14 (GPIO1_B3_d), U4.18 (SDO/PDMDATA)
/I2S1_SDO0: U1.B25 (GPIO1_A7_d), U4.17 (SDI)
/KEY_VOL_DN: C134.1, R31.1, R33.2, U1.1C17 (SARADC_VIN1)
/KEY_VOL_DN_BTN: C54.1, D8.1, J8.3, R33.1
/KEY_VOL_UP: C133.1, R30.1, R32.2, U1.1D17 (SARADC_VIN0)
/KEY_VOL_UP_BTN: C53.1, D7.1, J8.2, R32.1
/LCD_BL_PWM: R68.2, U1.1T19 (GPIO0_C0_d), U6.5 (CTRL)
/LCD_PWR_EN: R57.1, U1.1T18 (GPIO0_C6_d), U14.3 (ON), U15.4 (EN), U16.7 (SEL3), U16.14 (SEL2), U16.15 (SEL1)
/LCD_RST_L: D16.1, J1.37, U1.1R18 (GPIO0_C1_d)
/LPDDR4_A0_A: U1.C2 (AC11), U2.H2 (CA0_a)
/LPDDR4_A0_B: U1.A9 (AC13), U2.R2 (CA0_b)
/LPDDR4_A1_A: U1.C1 (AC2), U2.J2 (CA1_a)
/LPDDR4_A1_B: U1.B9 (AC6), U2.P2 (CA1_b)
/LPDDR4_A2_A: U1.1C1 (AC15), U2.H9 (CA2_a)
/LPDDR4_A2_B: U1.1B7 (AC18), U2.R9 (CA2_b)
/LPDDR4_A3_A: U1.1B3 (AC12), U2.H10 (CA3_a)
/LPDDR4_A3_B: U1.1B6 (AC4), U2.R10 (CA3_b)
/LPDDR4_A4_A: U1.1B1 (AC14), U2.H11 (CA4_a)
/LPDDR4_A4_B: U1.1A6 (AC19), U2.R11 (CA4_b)
/LPDDR4_A5_A: U1.1A1 (AC16), U2.J11 (CA5_a)
/LPDDR4_A5_B: U1.B8 (AC5), U2.P11 (CA5_b)
/LPDDR4_CKE0_A: U1.B4 (AC22), U2.J4 (CKE0_a)
/LPDDR4_CKE0_B: U1.1A3 (AC10), U2.P4 (CKE0_b)
/LPDDR4_CKE1_A: U1.1C3 (AC3), U2.J5 (CKE1_a)
/LPDDR4_CKE1_B: U1.1A2 (AC17), U2.P5 (CKE1_b)
/LPDDR4_CLKN_A: U1.B5 (AC24), U2.J9 (CK_c_a)
/LPDDR4_CLKN_B: U1.B7 (AC9), U2.P9 (CK_c_b)
/LPDDR4_CLKP_A: U1.A5 (AC23), U2.J8 (CK_t_a)
/LPDDR4_CLKP_B: U1.A7 (AC0), U2.P8 (CK_t_b)
/LPDDR4_CS0N_A: U1.B3 (AC25), U2.H4 (CS0_a)
/LPDDR4_CS0N_B: U1.1B5 (AC28), U2.R4 (CS0_b)
/LPDDR4_CS1N_A: U1.A3 (AC26), U2.H3 (CS1_a)
/LPDDR4_CS1N_B: U1.1A5 (AC27), U2.R3 (CS1_b)
/LPDDR4_DM0_A: U1.1E2 (DDR_DM0_A), U2.C3 (DMI0_a)
/LPDDR4_DM0_B: U1.1B8 (DDR_DM0_B), U2.Y3 (DMI0_b)
/LPDDR4_DM1_A: U1.1G1 (DDR_DM1_A), U2.C10 (DMI1_a)
/LPDDR4_DM1_B: U1.1A11 (DDR_DM1_B), U2.Y10 (DMI1_b)
/LPDDR4_DQ0_A: U1.G2 (DDR_DQ0_A), U2.B2 (DQ0_a)
/LPDDR4_DQ0_B: U1.B12 (DDR_DQ0_B), U2.AA2 (DQ0_b)
/LPDDR4_DQ1_A: U1.F2 (DDR_DQ1_A), U2.C2 (DQ1_a)
/LPDDR4_DQ1_B: U1.B10 (DDR_DQ1_B), U2.Y2 (DQ1_b)
/LPDDR4_DQ2_A: U1.F1 (DDR_DQ2_A), U2.E2 (DQ2_a)
/LPDDR4_DQ2_B: U1.1A8 (DDR_DQ2_B), U2.V2 (DQ2_b)
/LPDDR4_DQ3_A: U1.E1 (DDR_DQ3_A), U2.F2 (DQ3_a)
/LPDDR4_DQ3_B: U1.1A7 (DDR_DQ3_B), U2.U2 (DQ3_b)
/LPDDR4_DQ4_A: U1.M2 (DDR_DQ4_A), U2.F4 (DQ4_a)
/LPDDR4_DQ4_B: U1.B13 (DDR_DQ4_B), U2.U4 (DQ4_b)
/LPDDR4_DQ5_A: U1.K1 (DDR_DQ5_A), U2.E4 (DQ5_a)
/LPDDR4_DQ5_B: U1.1A10 (DDR_DQ5_B), U2.V4 (DQ5_b)
/LPDDR4_DQ6_A: U1.K2 (DDR_DQ6_A), U2.C4 (DQ6_a)
/LPDDR4_DQ6_B: U1.1B9 (DDR_DQ6_B), U2.Y4 (DQ6_b)
/LPDDR4_DQ7_A: U1.1E1 (DDR_DQ7_A), U2.B4 (DQ7_a)
/LPDDR4_DQ7_B: U1.1A9 (DDR_DQ7_B), U2.AA4 (DQ7_b)
/LPDDR4_DQ8_A: U1.P2 (DDR_DQ8_A), U2.B11 (DQ8_a)
/LPDDR4_DQ8_B: U1.B19 (DDR_DQ8_B), U2.AA11 (DQ8_b)
/LPDDR4_DQ9_A: U1.R1 (DDR_DQ9_A), U2.C11 (DQ9_a)
/LPDDR4_DQ9_B: U1.A19 (DDR_DQ9_B), U2.Y11 (DQ9_b)
/LPDDR4_DQ10_A: U1.R2 (DDR_DQ10_A), U2.E11 (DQ10_a)
/LPDDR4_DQ10_B: U1.A20 (DDR_DQ10_B), U2.V11 (DQ10_b)
/LPDDR4_DQ11_A: U1.T2 (DDR_DQ11_A), U2.F11 (DQ11_a)
/LPDDR4_DQ11_B: U1.B20 (DDR_DQ11_B), U2.U11 (DQ11_b)
/LPDDR4_DQ12_A: U1.M1 (DDR_DQ12_A), U2.F9 (DQ12_a)
/LPDDR4_DQ12_B: U1.A15 (DDR_DQ12_B), U2.U9 (DQ12_b)
/LPDDR4_DQ13_A: U1.1F2 (DDR_DQ13_A), U2.E9 (DQ13_a)
/LPDDR4_DQ13_B: U1.B15 (DDR_DQ13_B), U2.V9 (DQ13_b)
/LPDDR4_DQ14_A: U1.1F1 (DDR_DQ14_A), U2.C9 (DQ14_a)
/LPDDR4_DQ14_B: U1.1C10 (DDR_DQ14_B), U2.Y9 (DQ14_b)
/LPDDR4_DQ15_A: U1.1G2 (DDR_DQ15_A), U2.B9 (DQ15_a)
/LPDDR4_DQ15_B: U1.B16 (DDR_DQ15_B), U2.AA9 (DQ15_b)
/LPDDR4_DQS0N_A: U1.H1 (DDR_DQS0N_A), U2.E3 (DQS0_c_a)
/LPDDR4_DQS0N_B: U1.A12 (DDR_DQS0N_B), U2.V3 (DQS0_c_b)
/LPDDR4_DQS0P_A: U1.H2 (DDR_DQS0P_A), U2.D3 (DQS0_t_a)
/LPDDR4_DQS0P_B: U1.A13 (DDR_DQS0P_B), U2.W3 (DQS0_t_b)
/LPDDR4_DQS1N_A: U1.N2 (DDR_DQS1N_A), U2.E10 (DQS1_c_a)
/LPDDR4_DQS1N_B: U1.B17 (DDR_DQS1N_B), U2.V10 (DQS1_c_b)
/LPDDR4_DQS1P_A: U1.N1 (DDR_DQS1P_A), U2.D10 (DQS1_t_a)
/LPDDR4_DQS1P_B: U1.A17 (DDR_DQS1P_B), U2.W10 (DQS1_t_b)
/LPDDR4_ODT_CA_A: U1.E2 (AC8), U2.G2 (ODT_CA_a)
/LPDDR4_ODT_CA_B: U1.A10 (AC7), U2.T2 (ODT_CA_b)
/LPDDR4_RESETN: U1.1C7 (AC29), U2.T11 (RESET_n)
/LPDDR4_ZQ0: R19.1, U2.A5 (ZQ0)
/LPDDR4_ZQ1: R20.1, U2.A8 (ZQ1)
/MIPI_CSI_RX_CLK0N: J3.9, U1.1U9 (MIPI_CSI_RX_CLK0N)
/MIPI_CSI_RX_CLK0P: J3.8, U1.1V9 (MIPI_CSI_RX_CLK0P)
/MIPI_CSI_RX_CLK1N: J4.9, U1.1U8 (MIPI_CSI_RX_CLK1N)
/MIPI_CSI_RX_CLK1P: J4.8, U1.1V8 (MIPI_CSI_RX_CLK1P)
/MIPI_CSI_RX_D0N: J3.3, U1.AR18 (MIPI_CSI_RX_D0N)
/MIPI_CSI_RX_D0P: J3.2, U1.AP18 (MIPI_CSI_RX_D0P)
/MIPI_CSI_RX_D1N: J3.6, U1.AP17 (MIPI_CSI_RX_D1N)
/MIPI_CSI_RX_D1P: J3.5, U1.AR17 (MIPI_CSI_RX_D1P)
/MIPI_CSI_RX_D2N: J4.3, U1.AR15 (MIPI_CSI_RX_D2N)
/MIPI_CSI_RX_D2P: J4.2, U1.AP15 (MIPI_CSI_RX_D2P)
/MIPI_CSI_RX_D3N: J4.6, U1.AP14 (MIPI_CSI_RX_D3N)
/MIPI_CSI_RX_D3P: J4.5, U1.AR14 (MIPI_CSI_RX_D3P)
/MIPI_DSI_TX0_CLKN: J1.9, U1.1V15 (MIPI_DSI_TX0_CLKN/LVDS_TX0_CLKN)
/MIPI_DSI_TX0_CLKP: J1.8, U1.1V16 (MIPI_DSI_TX0_CLKP/LVDS_TX0_CLKP)
/MIPI_DSI_TX0_D0N: J1.3, U1.AR30 (MIPI_DSI_TX0_D0N/LVDS_TX0_D0N)
/MIPI_DSI_TX0_D0P: J1.2, U1.AP30 (MIPI_DSI_TX0_D0P/LVDS_TX0_D0P)
/MIPI_DSI_TX0_D1N: J1.6, U1.AP29 (MIPI_DSI_TX0_D1N/LVDS_TX0_D1N)
/MIPI_DSI_TX0_D1P: J1.5, U1.AR29 (MIPI_DSI_TX0_D1P/LVDS_TX0_D1P)
/MIPI_DSI_TX0_D2N: J1.12, U1.AR27 (MIPI_DSI_TX0_D2N/LVDS_TX0_D2N)
/MIPI_DSI_TX0_D2P: J1.11, U1.AP27 (MIPI_DSI_TX0_D2P/LVDS_TX0_D2P)
/MIPI_DSI_TX0_D3N: J1.15, U1.AP26 (MIPI_DSI_TX0_D3N/LVDS_TX0_D3N)
/MIPI_DSI_TX0_D3P: J1.14, U1.AR26 (MIPI_DSI_TX0_D3P/LVDS_TX0_D3P)
/MIPI_DSI_TX1_CLKN: J1.24, U1.1U11 (MIPI_DSI_TX1_CLKN)
/MIPI_DSI_TX1_CLKP: J1.23, U1.1V11 (MIPI_DSI_TX1_CLKP)
/MIPI_DSI_TX1_D0N: J1.18, U1.AR24 (MIPI_DSI_TX1_D0N)
/MIPI_DSI_TX1_D0P: J1.17, U1.AP24 (MIPI_DSI_TX1_D0P)
/MIPI_DSI_TX1_D1N: J1.21, U1.AP23 (MIPI_DSI_TX1_D1N)
/MIPI_DSI_TX1_D1P: J1.20, U1.AR23 (MIPI_DSI_TX1_D1P)
/MIPI_DSI_TX1_D2N: J1.27, U1.AR21 (MIPI_DSI_TX1_D2N)
/MIPI_DSI_TX1_D2P: J1.26, U1.AP21 (MIPI_DSI_TX1_D2P)
/MIPI_DSI_TX1_D3N: J1.30, U1.AP20 (MIPI_DSI_TX1_D3N)
/MIPI_DSI_TX1_D3P: J1.29, U1.AR20 (MIPI_DSI_TX1_D3P)
/MPR121_ELE0: R65.1, U9.8 (ELE0)
/PDM_CLK: MK1.2 (CLK), R46.1
/PDM_CLK_SOC: R46.2, U1.1A14 (GPIO1_A6_d)
/PDM_SDI: MK1.5 (DATA), U1.B26 (GPIO1_B2_d)
/PMIC_BATDIV: C72.1, R47.1, R48.2, U4.56 (BATDIV)
/PMIC_CPN: C33.2, U4.36 (CPN)
/PMIC_CPP: C33.1, U4.37 (CPP)
/PMIC_CPVSS: C34.1, U4.35 (VCC_CPVSS)
/PMIC_EXT_EN: R69.1, R78.1, U4.60 (EXT_EN), U8.A2 (EN), U12.1 (EN), U20.3 (EN)
/PMIC_FB1: C76.1, R53.2, U4.13 (FB1)
/PMIC_FB2: C77.1, R54.2, U4.8 (FB2)
/PMIC_FB3: R36.2, R37.1, U4.27 (FB3)
/PMIC_FB4: C78.1, R55.2, U4.64 (FB4)
/PMIC_INT_L: R4.1, U1.1R19 (GPIO0_A3_u), U4.7 (INT)
/PMIC_PWRON_L: C132.1, D44.2, U4.52 (PWRON)
/PMIC_RESETB: C52.1, R29.1, R94.2, U1.AG38 (nPOR_u), U4.67 (RESETB)
/PMIC_SLEEP: R43.1, R44.1, U4.49 (SLEEP), U8.A1 (VSEL)
/PMIC_SLEEP_3V3: R43.2, U1.1P19 (GPIO0_A2_d)
/PMIC_SW1: L1.1, U4.12 (SW1)
/PMIC_SW2: L2.1, U4.9 (SW2)
/PMIC_SW3: L3.1, U4.25 (SW3)
/PMIC_SW4: L4.1, U4.65 (SW4)
/PMIC_SW5: L5.1, U4.53 (SW5)
/PMIC_SWOUT1: C59.1, R80.1, TP31.1, U4.55 (SWOUT1), U21.4 (EN), U24.4 (EN)
/PMIC_VBUCK4: C63.1, C78.2, C120.2, C121.2, C122.1, C123.1, L4.2, R55.1, TP16.1, U1.1G15 (VDD_NPU_1), U1.1H14 (VDD_NPU_2), U1.1H15 (VDD_NPU_3), U1.1J14 (VDD_NPU_4), U1.1J15 (VDD_NPU_5)
/PMIC_VREF: C32.1, U4.46 (VREF)
/PWRON_BTN_L: D6.1, J8.1, R58.1
/PWRON_L: D44.1, D45.1, R58.2
/RTC_XIN: C22.1, U4.50 (XIN), Y2.1
/RTC_XOUT: C23.1, U4.51 (XOUT), Y2.2
/SPK_AMP_EN: R88.1, U1.1B13 (GPIO1_B0_d), U10.1 (CTRL), U23.1 (CTRL)
/SPK_BOT_N: C138.1, D38.1, J9.3, J9.4, L16.2
/SPK_BOT_OUT_N: L16.1, U10.5 (VON)
/SPK_BOT_OUT_P: L15.1, U10.8 (VoP)
/SPK_BOT_P: C137.1, D37.1, J9.1, J9.2, L15.2
/SPK_TOP_N: C136.1, D36.1, J7.3, J7.4, L14.2
/SPK_TOP_OUT_N: L14.1, U23.5 (VON)
/SPK_TOP_OUT_P: L13.1, U23.8 (VoP)
/SPK_TOP_P: C135.1, D35.1, J7.1, J7.2, L13.2
/TP_COF_INT_L: D21.1, J2.4, R64.1, U16.8 (D3)
/TP_ELE0: D23.1, J2.10, R65.2
/TP_I2C1_SCL: D19.1, J2.2, R62.1, U16.16 (D1)
/TP_I2C1_SDA: D20.1, J2.3, R63.1, U16.13 (D2)
/TP_INT_L: R5.1, U1.1U20 (GPIO0_B5_u), U16.9 (S3)
/TP_REXT: R14.1, U9.7 (REXT)
/TP_RST_L: D22.1, J2.5, R61.1, U1.1V20 (GPIO0_C7_d)
/TP_SAR_INT_L: R38.1, U1.1U19 (GPIO0_C5_d), U9.1 (~IRQ)
/TSADC_SHUT: R94.1, U1.1R20 (GPIO0_A1_z)
/UART2_RX: R60.1, U1.1V19 (GPIO0_D0_u)
/UART2_RX_TP: D40.1, R60.2, TP2.1
/UART2_TX: R59.1, U1.1U18 (GPIO0_D1_u)
/UART2_TX_TP: D39.1, R59.2, TP1.1
/USB_CC1: D11.1, J6.4, R49.1, U22.2 (S1)
/USB_CC1_ADC: C73.1, U1.1B18 (SARADC_VIN2), U22.3 (D1)
/USB_CC2: D12.1, J6.5, R50.1, U22.10 (S3)
/USB_CC2_ADC: C74.1, U1.1A19 (SARADC_VIN3), U22.9 (D3)
/USB_OTG0_DM: D10.1, J6.2, U1.R38 (USB_OTG0_DM)
/USB_OTG0_DP: D9.1, J6.1, U1.R37 (USB_OTG0_DP)
/VBAT: C8.1, C129.2, C130.2, D3.1 (C), Q1.4 (S1), Q1.8 (S2), R47.2, R66.2, TP8.1, U11.13 (BAT), U11.14 (BAT)
/VBAT_CONN: F1.1, J5.1, TP6.1
/VBAT_PROT: F1.2, Q1.1 (D1), Q1.2 (D2), Q1.5 (D3), Q1.6 (D4), Q1.7 (D5), R70.2, R72.1, TP7.1
/VBAT_RPP_EN: D49.1, Q2.1 (G), R70.1, R71.1
/VBAT_RPP_G: Q1.3 (G), Q2.3 (D), R66.1
/VBAT_WAKE: D43.1, R72.2
/VBUS: C7.1, C159.1, D13.1, J6.11, J6.12, J6.13, J6.14, J6.15, J6.16, R34.1, TP5.1, U11.1 (VBUS)
/VBUS_DET: C57.1, R34.2, R35.1, U1.T38 (USB_OTG0_VBUSDET), U4.61 (VDC)
/VCC0V6_DDR: C42.1, C71.1, L12.2, R19.2, R20.2, TP19.1, U1.1E6 (DDR_VDDQL_1), U1.1E7 (DDR_VDDQL_2), U1.1E9 (DDR_VDDQL_3), U1.1F5 (DDR_VDDQL_4), U1.1G5 (DDR_VDDQL_5), U2.AA3 (VDDQ), U2.AA5 (VDDQ), U2.AA8 (VDDQ), U2.AA10 (VDDQ), U2.B3 (VDDQ), U2.B5 (VDDQ), U2.B8 (VDDQ), U2.B10 (VDDQ), U2.D1 (VDDQ), U2.D5 (VDDQ), U2.D8 (VDDQ), U2.D12 (VDDQ), U2.F3 (VDDQ), U2.F10 (VDDQ), U2.U3 (VDDQ), U2.U10 (VDDQ), U2.W1 (VDDQ), U2.W5 (VDDQ), U2.W8 (VDDQ), U2.W12 (VDDQ), U13.1 (FB)
/VCC1V8_CAM: C31.1, C60.1, D29.1, J3.19, J3.20, J4.19, J4.20, R17.2, R18.2, R84.2, R85.2, TP26.1, U4.3 (LDO7)
/VCC1V8_DDR: C144.1, C149.2, C150.1, R79.1, TP39.1, U2.F1 (VDD1), U2.F12 (VDD1), U2.G4 (VDD1), U2.G9 (VDD1), U2.T4 (VDD1), U2.T9 (VDD1), U2.U1 (VDD1), U2.U12 (VDD1), U17.5 (VCC), U20.5 (OUT)
/VCC1V8_LCD: C128.2, D17.1, J1.32, J1.33, J2.7, J2.8, R62.2, R63.2, R64.2, TP33.1, U14.5 (QOD), U14.6 (VOUT)
/VCC3V3_EMMC: C153.1, C154.2, C157.2, C184.1, TP41.1, U1.1N5 (VCCIO5_1), U1.1N6 (VCCIO5_2), U1.1N8 (VCCIO7), U3.E6 (VCC), U3.F5 (VCC), U3.J10 (VCC), U3.K9 (VCC), U24.1 (OUT)
/VCC3V3_LCD: C38.1, D18.1, J1.35, J1.36, J2.6, TP34.1, U15.1 (OUT)
/VCC3V3_PMU: C30.1, C56.1, R4.2, R29.2, R52.1, TP25.1, U1.1P16 (PMUIO1), U4.31 (LDO6)
/VCC3V3_SYS: C5.1, C65.1, C147.1, C183.1, R39.1, TP40.1, U4.30 (VCC6), U4.57 (VCC8), U12.6 (VOUT), U21.6 (IN), U24.6 (IN), U25.6 (VIN2)
/VCC3V3_TP: C37.1, TP32.1, U4.58 (SWOUT2), U15.6 (IN)
/VCCA1V8_CODEC: C29.1, TP23.1, U4.28 (LDO4), U4.38 (VCC_CPVDD), U4.44 (VCC_1P8A)
/VCCA1V8_IMAGE: C127.2, C142.2, C143.1, TP27.1, U1.1G17 (EDP_TX_AVDD_1V8), U1.1P9 (MIPI_CSI_RX_AVDD_1V8), U1.1P12 (MIPI_DSI_TX0/LVDS_TX0_AVDD_1V8), U1.1P13 (HDMI_TX_AVDD_1V8), U1.1R10 (MIPI_DSI_TX1_AVDD_1V8), U4.5 (LDO8)
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